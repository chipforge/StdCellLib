* gnetlist -g spice-sdb -o TBench/spice/LATN_tb.sp TBench/geda/LATN_tb.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from Library/spice/LATN.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT LATN Q D XN VDD GND
*vvvvvvvv  Included SPICE model from Technology/spice/ls1unmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL NMOS4 NMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.5
+ PHI    = 0.7             VTO    = 0.8             DELTA  = 3.0
+ UO     = 650             ETA    = 3.0E-6          THETA  = 0.1
+ KP     = 120E-6          VMAX   = 1E5             KAPPA  = 0.3
+ RSH    = 0               NFS    = 1E12            TPG    = 1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5

*^^^^^^^^  End of included SPICE model from Technology/spice/ls1unmos.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Technology/spice/ls1upmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL PMOS4 PMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.6
+ PHI    = 0.7             VTO    = -0.9            DELTA  = 0.1
+ UO     = 250             ETA    = 0               THETA  = 0.1
+ KP     = 40E-6           VMAX   = 5E4             KAPPA  = 1
+ RSH    = 0               NFS    = 1E12            TPG    = -1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5
*^^^^^^^^  End of included SPICE model from Technology/spice/ls1upmos.mod ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M11 3 clk180 VDD VDD pmos4  l=1u w='2*PNratio*Wunit'
M14 4 clk360 0 0 nmos4  l=1u w='2*Wunit'
M13 q_n Q 4 0 nmos4  l=1u w='2*Wunit'
M12 q_n Q 3 VDD pmos4  l=1u w='2*PNratio*Wunit'
M10 Q q_n 0 0 nmos4  l=1u w='Wunit'
M9 Q q_n VDD VDD pmos4  l=1u w='PNratio*Wunit'
M5 1 clk360 VDD VDD pmos4  l=1u w='2*PNratio*Wunit'
M8 2 clk180 0 0 nmos4  l=1u w='2*Wunit'
M7 q_n D 2 0 nmos4  l=1u w='2*Wunit'
M6 q_n D 1 VDD pmos4  l=1u w='2*PNratio*Wunit'
M2 clk180 XN 0 0 nmos4  l=1u w='Wunit'
M4 clk360 clk180 0 0 nmos4  l=1u w='Wunit'
M3 clk360 clk180 VDD VDD pmos4  l=1u w='PNratio*Wunit'
.PARAM PNratio=2
.PARAM Wunit=1.5u
M1 clk180 XN VDD VDD pmos4  l=1u w='PNratio*Wunit'
.ends LATN
*******************************
*^^^^^^^^  End of included SPICE model from Library/spice/LATN.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Library/spice/BUF2.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT BUF2 Z A VDD GND
*vvvvvvvv  Included SPICE model from Technology/spice/ls1unmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL NMOS4 NMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.5
+ PHI    = 0.7             VTO    = 0.8             DELTA  = 3.0
+ UO     = 650             ETA    = 3.0E-6          THETA  = 0.1
+ KP     = 120E-6          VMAX   = 1E5             KAPPA  = 0.3
+ RSH    = 0               NFS    = 1E12            TPG    = 1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5

*^^^^^^^^  End of included SPICE model from Technology/spice/ls1unmos.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Technology/spice/ls1upmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL PMOS4 PMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.6
+ PHI    = 0.7             VTO    = -0.9            DELTA  = 0.1
+ UO     = 250             ETA    = 0               THETA  = 0.1
+ KP     = 40E-6           VMAX   = 5E4             KAPPA  = 1
+ RSH    = 0               NFS    = 1E12            TPG    = -1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5
*^^^^^^^^  End of included SPICE model from Technology/spice/ls1upmos.mod ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
.PARAM PNratio=2
.PARAM Wunit=1.5u
M3 Z 1 VDD VDD pmos4  l=1u w='2*PNratio*Wunit'
M1 1 A VDD VDD pmos4  l=1u w='PNratio*Wunit'
M4 Z 1 0 0 nmos4  l=1u w='2*Wunit'
M2 1 A 0 0 nmos4  l=1u w='Wunit'
.ends BUF2
*******************************
*^^^^^^^^  End of included SPICE model from Library/spice/BUF2.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Library/spice/FO4.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT FO4 Z A VDD GND
*vvvvvvvv  Included SPICE model from Technology/spice/ls1unmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL NMOS4 NMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.5
+ PHI    = 0.7             VTO    = 0.8             DELTA  = 3.0
+ UO     = 650             ETA    = 3.0E-6          THETA  = 0.1
+ KP     = 120E-6          VMAX   = 1E5             KAPPA  = 0.3
+ RSH    = 0               NFS    = 1E12            TPG    = 1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5

*^^^^^^^^  End of included SPICE model from Technology/spice/ls1unmos.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Technology/spice/ls1upmos.mod vvvvvvvv
*
* Long channel models from CMOS Circuit Design, Layout, and Simulation,
* Level=3 models VDD=5V, see CMOSedu.com
*
.MODEL PMOS4 PMOS LEVEL  = 3
+ TOX    = 200E-10         NSUB   = 1E17            GAMMA  = 0.6
+ PHI    = 0.7             VTO    = -0.9            DELTA  = 0.1
+ UO     = 250             ETA    = 0               THETA  = 0.1
+ KP     = 40E-6           VMAX   = 5E4             KAPPA  = 1
+ RSH    = 0               NFS    = 1E12            TPG    = -1
+ XJ     = 500E-9          LD     = 100E-9
+ CGDO   = 200E-12         CGSO   = 200E-12         CGBO   = 1E-10
+ CJ     = 400E-6          PB     = 1               MJ     = 0.5
+ CJSW   = 300E-12         MJSW   = 0.5
*^^^^^^^^  End of included SPICE model from Technology/spice/ls1upmos.mod ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
.PARAM Fan=4
.PARAM PNratio=2
.PARAM Wunit=1.5u
M3 Z 1 VDD VDD pmos4  l=1u w='Fan*Fan*PNratio*Wunit'
M1 1 A VDD VDD pmos4  l=1u w='Fan*PNratio*Wunit'
M4 Z 1 0 0 nmos4  l=1u w='Fan*Fan*Wunit'
M2 1 A 0 0 nmos4  l=1u w='Fan*Wunit'
.ends FO4
*******************************
*^^^^^^^^  End of included SPICE model from Library/spice/FO4.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
XUT Q D XN Vdd 0 LATN
XQ 4 Q Vdd 0 FO4
XXN XN 1 Vdd 0 BUF2
XD D 2 Vdd 0 BUF2
RL 4 3 100k
CL 3 0 10n
V2 2 0 pulse 0 'SUPPLY' 5n 7.5n 7.5n 15n 60n
V3 1 0 pulse 0 'SUPPLY' 0.5n 7.5n 7.5n 7.5n 30n
.param SUPPLY=5.0
.INCLUDE TBench/spice/LATN_tb.cmd
VDD Vdd 0 DC 'SUPPLY'
.end
